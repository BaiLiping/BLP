<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Jan_6\Embedded_System_Basics.ewp</path>
    </project>
    <batchBuild />
</workspace>
