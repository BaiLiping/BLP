<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Phased_Array.ewp</path>
    </project>
    <batchBuild />
</workspace>
